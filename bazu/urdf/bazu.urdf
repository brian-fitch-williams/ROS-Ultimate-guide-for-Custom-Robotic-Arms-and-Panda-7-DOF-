Commit message: Fixes for arm axis other

File: bazu/urdf/bazu.urdf (robot description, URDF)
Before this commit: robot bazu, 6 links, 5 joints
Joints:
- joint joint_3: axis 0 0 1 -> 0 1 0
